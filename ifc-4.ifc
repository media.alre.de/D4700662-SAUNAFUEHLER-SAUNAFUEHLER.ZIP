Properties of the parts of a building model (IFC4)

# File
Description: Ersatzfühler/STB für Saunasteuerungen Saunatherm VU/Hygrotherm VU, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: D4700662, Ersatzfühler/STB für Saunasteuerungen Saunatherm VU/Hygrotherm VU
In: Raum
Description: Ersatzfühler/STB für Saunasteuerungen Saunatherm VU/Hygrotherm VU, STB 141 °C; Classification: EC001885 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: D4700662; ModelLabel: Saunafühler; GlobalTradeItemNumber: 4050528022035; ProductURL: https://alre.de/produkt_D4700662
Pset_Specification - NominalLength: 0.0655 m; NominalWidth: 0.04 m; NominalDepth: 0.027 m; NetWeight: 0.138
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: sonstige; Ersatzteil: yes; ETIM-Klasse: EC001885; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-D4700662.pdf
